options:
  parameters:
    author: Ivan Iudice
    generate_options: qt_gui
    id: cyc_cross_corr
    output_language: python
    title: Cyclic Cross-Correlation
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '[0, 1/8]'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: max_lag
  id: variable
  parameters:
    value: '256'
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: win_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: CycloDSP_CycXCorr_0
  id: CycloDSP_CycXCorr
  parameters:
    alpha: '[0,1/samp_sym]'
    conj: 'False'
    lags: '[0]'
    max_lag: max_lag
    mode: '0'
    state: '1'
    win_len: win_len
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: win_len
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_2
  id: blocks_complex_to_mag
  parameters:
    vlen: 2*max_lag+1
  states: {}
- name: blocks_complex_to_mag_2_1
  id: blocks_complex_to_mag
  parameters:
    vlen: 2*max_lag+1
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: 2*max_lag+1
  states: {state: bypassed}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: 2*max_lag+1
  states: {state: bypassed}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
    vlen: 2*max_lag+1
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: samp_sym
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    label1: '"alpha="+str(alpha[0])'
    update_time: refresh_rate
    vlen: 2*max_lag+1
    x_axis_label: '"Tau (ms)"'
    x_start: '-max_lag*1000/samp_rate'
    x_step: 1000/samp_rate
    y_axis_label: '"CCF"'
    ymax: '4'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,1,1
    label1: '"alpha="+str(alpha[1])'
    update_time: refresh_rate
    vlen: 2*max_lag+1
    x_axis_label: '"Tau (ms)"'
    x_start: '-max_lag*1000/samp_rate'
    x_step: 1000/samp_rate
    y_axis_label: '"CCF"'
    ymax: '4'
    ymin: '0'
  states: {}

connections:
- [CycloDSP_CycXCorr_0, '0', blocks_vector_to_streams_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_complex_to_mag_2, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_2_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_throttle_0, '0', CycloDSP_CycXCorr_0, '0']
- [blocks_throttle_0, '0', CycloDSP_CycXCorr_0, '1']
- [blocks_vector_to_streams_0, '0', blocks_complex_to_mag_2, '0']
- [blocks_vector_to_streams_0, '1', blocks_complex_to_mag_2_1, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
